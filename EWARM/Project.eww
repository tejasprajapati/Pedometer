<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\tut7_SSD1306.ewp</path>
  </project>
  <batchBuild />
</workspace>
